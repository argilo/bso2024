options:
  parameters:
    generate_options: no_gui
    id: hop
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: flag1
  id: variable
  parameters:
    value: '"flag{FSK_FTW}"'
  states: {}
- name: flag2
  id: variable
  parameters:
    value: '"flag{jU5t_h0Pp1Ng_aL0nG}"'
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '48'
  states: {}
- name: packets
  id: variable
  parameters:
    value: '[([0] * padding) + ([0b01010101] * 8) + sync_word + [ord(c) for c in piece] + ([0] * padding) for piece in pieces]'
  states: {}
- name: padding
  id: variable
  parameters:
    value: '16'
  states: {}
- name: pieces
  id: variable
  parameters:
    value: '["Flag 1: " + flag1 + f" Flag 2: seq={i:02} data={c}" for i, c in enumerate(flag2)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: audio_rate // baud_rate
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0xd3, 0x91]'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32768'
    vector_output: 'False'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: (samp_rate // baud_rate) * len(packets[0]) * 8
    type: float
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Clayton Smith
    center_freq: np.nan
    filename: hop
    sample_rate: samp_rate
    type: complex short (sc16_le)
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.88'
    samp_rate: audio_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_vco_c_1
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[b for packet in packets for b in packet]'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ([0] * (8 * sps * (padding-1))) + ([1] * (8 * sps * (2 + 8 + len(sync_word) + len(pieces[0])))) + ([0] * (8 * sps * (padding-1)))
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[(chan_spacing / 2) + chan * chan_spacing for chan in random.sample(range(-(num_channels // 2), num_channels // 2), len(flag2))]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-deviation, +deviation]'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: deviation * 2
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: ccc
    width: deviation / 2
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_multiply_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_1, '0']
- [blocks_repeat_0, '0', blocks_vco_c_1, '0']
- [blocks_repeat_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vco_c_1, '0', blocks_multiply_xx_1, '1']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_2, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_vco_c_0, '0']
- [filter_fft_low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
