options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: blade_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: samp_rate / interpolation
  states: {}
- name: band
  id: variable
  parameters:
    value: '926.900'
  states: {}
- name: correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cw_vector
  id: variable
  parameters:
    value: morse_seq("ve3irr   the flag is cucumber   ")*1000
  states: {}
- name: i_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    start: '-0.2'
    step: '0.0005'
    stop: '0.2'
    value: '0.045'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '80'
  states: {}
- name: mag
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0, 1, 1
    start: '-0.2'
    step: '0.001'
    stop: '0.2'
    value: '0.035'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 0, 1, 1
    start: '-0.2'
    step: '0.001'
    stop: '0.2'
    value: '0.066'
  states: {}
- name: q_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    start: '-0.2'
    step: '0.0005'
    stop: '0.2'
    value: '0.015'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tune
  id: variable
  parameters:
    value: '100'
  states: {}
- name: wpm
  id: variable
  parameters:
    value: '15'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.000001'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: i_off + q_off * 1j
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * (tune * 1000 + 100000) / samp_rate
  states: {}
- name: click_filter
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-2'
    type: complex
  states: {}
- name: cw_repeat
  id: blocks_repeat
  parameters:
    interp: int(1.2 * audio_rate / wpm)
    type: complex
  states: {}
- name: cw_vector_source
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: cw_vector
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from morse_table import morse_seq
  states: {}
- name: iqbalance_fix_cc_0
  id: iqbalance_fix_cc
  parameters:
    mag: mag
    phase: phase
  states: {}
- name: resamp
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interpolation
    taps: ''
    type: ccc
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: (band * 1e6 + 100000 - offset) * (1 + correction*1e-6)
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', resamp, '0']
- [blocks_add_const_vxx_0_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', cw_repeat, '0']
- [blocks_rotator_cc_0, '0', iqbalance_fix_cc_0, '0']
- [click_filter, '0', blocks_add_const_vxx_0, '0']
- [cw_repeat, '0', click_filter, '0']
- [cw_vector_source, '0', blocks_multiply_const_vxx_0, '0']
- [iqbalance_fix_cc_0, '0', blocks_add_const_vxx_0_0, '0']
- [resamp, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
