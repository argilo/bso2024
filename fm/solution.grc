options:
  parameters:
    generate_options: qt_gui
    id: solution
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '50'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: fsk_baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: fsk_offset
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: fsk_deviation * 2
    gain: '1.0'
    samp_rate: samp_rate
    width: fsk_deviation / 2
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*deviation)
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate // decim)/(2*math.pi*fsk_deviation)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: part4_bits.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: broadcast.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: (samp_rate // decim) / fsk_baud
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fsk_offset
    decim: decim
    samp_rate: samp_rate
    taps: lp_taps
    type: fcf
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '1024'
    srate: fsk_baud
    style1: '0'
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_quadrature_demod_cf_1, '0', digital_symbol_sync_xx_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
