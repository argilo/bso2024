options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: paint_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32768'
    vector_output: 'False'
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Clayton Smith
    center_freq: np.nan
    filename: outfile
    sample_rate: samp_rate
    type: complex short (sc16_le)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '192'
    input_size: '4096'
    tagname: ''
  states: {}
- name: infile
  id: parameter
  parameters:
    type: str
    value: flag.png
  states: {}
- name: outfile
  id: parameter
  parameters:
    type: str
    value: paint
  states: {}
- name: paint_image_source_1
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: infile
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '12'
    width: '1500'
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_stream_to_vector_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [paint_image_source_1, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
