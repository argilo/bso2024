options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: paint_tx
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.25'
    stop: '89'
    value: '70'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32768'
    vector_output: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Clayton Smith
    center_freq: np.nan
    filename: paint
    sample_rate: samp_rate
    type: complex short (sc16_le)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4096'
    type: complex
  states: {state: disabled}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '192'
    input_size: '4096'
    tagname: ''
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(4096)
  states: {state: disabled}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: fionna.png
    image_flip: '0'
    image_invert: '0'
    repeatmode: '1'
  states: {state: disabled}
- name: paint_image_source_1
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: flag.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '12'
    width: '1500'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '4096'
    type: complex
    xmax: '15'
    xmin: '-15'
    ymax: '15'
    ymin: '-15'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_max: '-51'
    int_min: '-77'
    showports: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(frequency, 950000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: paint-cyclic
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: paint-cyclic
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_throttle_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', uhd_usrp_sink_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_image_source_1, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_stream_to_vector_0, '0']
- [paint_paint_bc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', digital_ofdm_cyclic_prefixer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
