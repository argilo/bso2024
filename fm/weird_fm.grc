options:
  parameters:
    generate_options: qt_gui
    id: weird_fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cw_amplitude
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: cw_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: db_range
  id: variable
  parameters:
    value: '60'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: fm_amplitude
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: fsk_amplitude
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: fsk_baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: fsk_message
  id: variable
  parameters:
    value: '"Lorem ipsum dolor sit amet, consectetur adipiscing elit, sed do eiusmod tempor incididunt ut labore et dolore magna aliqua. Ut enim ad minim veniam, quis nostrud exercitation ullamco laboris nisi ut aliquip ex ea commodo consequat. Duis aute irure dolor in reprehenderit in voluptate velit esse cillum dolore eu fugiat nulla pariatur. Excepteur sint occaecat cupidatat non proident, sunt in culpa qui officia deserunt mollit anim id est laborum. " * 10 + "Part 4: flag{frEqu3nCy_sH1F7_k3y1nG} "'
  states: {}
- name: fsk_offset
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: fsk_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: lsb_amplitude
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: lsb_offset
  id: variable
  parameters:
    value: '44000'
  states: {}
- name: lsb_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: lsb_wav_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: mp3_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: paint_amplitude
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: paint_offset
  id: variable
  parameters:
    value: '37000'
  states: {}
- name: rds_flag
  id: variable
  parameters:
    value: '"flag{foo_bar_baz_cux}"'
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: 2000 / deviation
  states: {}
- name: rds_offset
  id: variable
  parameters:
    value: '57000'
  states: {}
- name: rds_rate
  id: variable
  parameters:
    value: '380000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: wpm
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1'
    samp_rate: mp3_rate
    tau: '50e-6'
  states: {state: bypassed}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * deviation / samp_rate
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1000'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*deviation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: rds_gain
    freq: rds_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '40000'
    freq: 1 / 123
    offset: '0'
    phase: math.pi - 0.5
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: 2 * lsb_amplitude
    high_cutoff_freq: '-200'
    interp: '1'
    low_cutoff_freq: '-2800'
    samp_rate: lsb_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-fft_size'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: float
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32768'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: demod.cf32
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: demod.f32
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: fft_size
    n: fft_size * 2
    offset: '0'
    type: complex
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.log(10**(db_range/20)) / fft_size
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10 / fft_size
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: paint_amplitude
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cw_amplitude
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(1.2 * cw_rate / wpm)
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: fsk_rate // fsk_baud
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: paint_offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: lsb_offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_rotator_cc_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: fsk_offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Clayton Smith
    center_freq: np.nan
    filename: broadcast
    sample_rate: samp_rate
    type: complex short (sc16_le)
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '8040000'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: exp
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: fsk_amplitude
    samp_rate: fsk_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0,)*110 + morse_table.morse_seq("Hello GNU Radio Conference. For part 1 the flag is electromagnetism") + (0,)*110
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(c) for c in fsk_message]'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Phish Funk - Beautiful Geometry.mp3
    nchan: '2'
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: flag3.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-fsk_deviation, +fsk_deviation]'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_size
    input_size: fft_size
    rolloff: fft_size
    tagname: ''
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: fsk_deviation * 2
    decim: '1'
    gain: '1'
    samp_rate: fsk_rate
    type: ccc
    width: fsk_deviation / 2
    win: window.WIN_HAMMING
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import morse_table
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: fm_amplitude
    samp_rate: mp3_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: flag1.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / mp3_rate
    type: fff
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate / fsk_rate * 1.0010951597837716
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_level: '1.0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // 4800
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // cw_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // lsb_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: rds_rate
    interp: samp_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // 240000
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_3_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: lsb_rate // lsb_wav_rate
    type: fff
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 88.0e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '1337'
    ps: HexPulse
    pty: '9'
    pty_locale: '0'
    radiotext: rds_flag
    ta: 'False'
    tp: 'False'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '0.95'
    ntaps: '200'
    samp_rate: cw_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '160'
    gain: '111'
    interp: '160'
    ntaps: 160*11
    samp_rate: rds_rate
    sym_rate: '2375'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: cw_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: paint
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: cw
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: fm
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: lsb
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: fsk
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: rds
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: paint
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: cw
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: fm
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: lsb
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: fsk
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: rds
  states: {}

connections:
- [analog_fm_preemph_0, '0', pfb_arb_resampler_xxx_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_3, '0']
- [analog_noise_source_x_0_0, '0', blocks_magphase_to_complex_0, '1']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_3, '0']
- [analog_sig_source_x_0, '0', gr_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_vco_c_0, '0']
- [band_pass_filter_0_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', blocks_skiphead_0, '0']
- [blocks_add_xx_2, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_add_xx_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_complex_to_real_1, '0', virtual_sink_3, '0']
- [blocks_complex_to_real_2, '0', virtual_sink_4, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_1, '0']
- [blocks_float_to_complex_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_magphase_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_2, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_3, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_multiply_const_vxx_3, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_1, '0']
- [blocks_repeat_0, '0', root_raised_cosine_filter_1, '0']
- [blocks_repeat_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_rotator_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_1, '0']
- [blocks_rotator_cc_0_1, '0', blocks_complex_to_real_2, '0']
- [blocks_skiphead_0, '0', low_pass_filter_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_transcendental_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vco_c_0_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_add_xx_0, '1']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_3_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_vco_c_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_keep_m_in_n_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [filter_fft_low_pass_filter_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', virtual_sink_5, '0']
- [gr_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [low_pass_filter_0, '0', analog_fm_preemph_0, '0']
- [paint_image_source_0, '0', blocks_uchar_to_float_0, '0']
- [pfb_arb_resampler_xxx_0, '0', virtual_sink_2, '0']
- [pfb_arb_resampler_xxx_0_0, '0', blocks_rotator_cc_0_1, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_rotator_cc_0_0, '0']
- [rational_resampler_xxx_2, '0', gr_multiply_xx_0, '0']
- [rational_resampler_xxx_3, '0', blocks_file_sink_2, '0']
- [rational_resampler_xxx_3, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_3_0, '0', blocks_float_to_complex_0_0, '0']
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_1, '0']
- [root_raised_cosine_filter_0_0, '0', rational_resampler_xxx_2, '0']
- [root_raised_cosine_filter_1, '0', root_raised_cosine_filter_0, '0']
- [virtual_source_0, '0', blocks_add_xx_2, '1']
- [virtual_source_1, '0', blocks_add_xx_2, '2']
- [virtual_source_2, '0', blocks_add_xx_2, '0']
- [virtual_source_3, '0', blocks_add_xx_2, '3']
- [virtual_source_4, '0', blocks_add_xx_2, '4']
- [virtual_source_5, '0', blocks_add_xx_2, '5']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
